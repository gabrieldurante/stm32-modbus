# IAR project Project.ewp, settings and files
configuration STM32100B-EVAL (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: ..\; ..\Libraries\; ..\Libraries\CMSIS\CM3\CoreSupport; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\STM32F10x_StdPeriph_Driver\src; ..\modbus; ..\modbus\ascii; ..\modbus\functions; ..\modbus\include; ..\modbus\port; ..\modbus\rtu; ..\modbus\tcp; ..\modbus\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: ..\; ..\Libraries\; ..\Libraries\CMSIS\CM3\CoreSupport; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\STM32F10x_StdPeriph_Driver\src
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210C-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
configuration STM3210E-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
configuration STM32100E-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100xE ST STM32F100xE
configuration STM3210E-EVAL_XL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxG ST STM32F10xxG
  group CMSIS
    ../: system_stm32f10x.c
  group Doc
    ./: readme.txt
  group Modbus
    ../modbus/port/: assert.h port.c port.h portevent.c portserial.c porttimer.c
    ../modbus/: mb.c
    ../modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
    ../modbus/ascii/: mbascii.c mbascii.h
    ../modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../modbus/tcp/: mbtcp.c mbtcp.h
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../: main.c stm32f10x_it.c
